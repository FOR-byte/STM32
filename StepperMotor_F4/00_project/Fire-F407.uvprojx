# Keil uVision project Fire-F407.uvprojx, settings and files
target TIM (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\00_project;..\01_fwlib\CMSIS\Include;..\01_fwlib\CMSIS\Device\ST\STM32F4xx\Include;..\01_fwlib\STM32F4xx_HAL_Driver\Inc;..\01_fwlib\STM32F4xx_HAL_Driver\Inc\Legacy;..\02_user;..\03_bsp\delay;..\03_bsp\key;..\03_bsp\led;..\03_bsp\stepper;..\03_bsp\tim;..\03_bsp\usart;..\03_bsp\encoder;..\05_drv\stepper
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ../01_fwlib/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group cmsis
    ../02_user/: system_stm32f4xx.c
  group fwlib
    ../01_fwlib/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_exti.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group drv
    ../05_drv/stepper/: drv_stepper_T_speed.c drv_stepper_S_speed.c
  group bsp
    ../03_bsp/key/: bsp_exti.c
    ../03_bsp/led/: bsp_led.c
    ../03_bsp/delay/: bsp_delay.c
    ../03_bsp/usart/: bsp_debug_usart.c
    ../03_bsp/stepper/: bsp_stepper_init.c
    ../03_bsp/encoder/: bsp_encoder.c
  group user
    ../02_user/: main.c stm32f4xx_it.c
  group doc
    ../06_doc/: readme.txt
